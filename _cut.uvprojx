# Keil uVision project _cut.uvprojx, settings and files
target cut (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_Remote +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CMSIS;..\StdPeriph_Driver\inc;..\uCOS-II\Ports;..\uCOS-II\Source;..\duanxianV4.2;..\FreeModbus\modbus\include;..\FreeModbus\modbus\ascii;..\FreeModbus\modbus\functions;..\FreeModbus\modbus\rtu;..\FreeModbus\modbus\tcp;..\FreeModbus\port;.\tasks\cut_tool;.\drv;..\robot-disconnection-tool;.\tasks
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group drv
    ./drv/: drv_motocan.c dj_motor.c steering_motor.c drv_adc1.c drv_can.c drv_dog.c drv_flash.c drv_time3_pwm.c drv_usart.c iap.c PID.c
    ./tasks/: v3tov2.c
  group USER
    ./tasks/: main.c task_protocol.c user_settings.c user_tasks.c
    ./tasks/cut_tool/: cut_tool.c grip.c
    ./: stm32f10x_it.c
  group StartUP
    ./: startup_stm32f10x_md.s
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group StdPeriph_Driver
    ../StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_flash.c stm32f10x_spi.c stm32f10x_can.c stm32f10x_adc.c stm32f10x_dma.c
  group uCOS-II\Src
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II\Ports
    ../uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group Note
    ./: Note.txt
target cutBoot (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: Fire_Remote +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
